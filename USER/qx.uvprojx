# Keil uVision project qx.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: qx +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\USART;..\HARDWARE\DHCP;..\HARDWARE\Ethernet;..\HARDWARE\Ethernet\W5500;..\HARDWARE\LED;..\HARDWARE\qxwz_sdk;..\HARDWARE\SPI;..\HARDWARE\TIME;..\FWLIB\inc;..\DELAY;..\CORE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_rtc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group HANDLAY
    ../DELAY/: delay.c
    ../USART/: usart.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/TIME/: Time_test.c
    ./: OLED.c
